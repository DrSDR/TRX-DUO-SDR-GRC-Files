options:
  parameters:
    author: drsdr
    generate_options: qt_gui
    id: trxduo_NBFM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.5236'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: sensitivity = (2*pi*deviation)/FS
  states: {}
- name: note_1
  id: note
  parameters:
    note: (2*pi*4e3)/48e3 = 0.5236
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: redpitaya=192.168.1.100:1001
    bb_gain0: '20'
    freq0: 27e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 50e3
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '25'
    type: ccc
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
